# Keil uVision project main.uvproj, settings and files
target SmartHead (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\STlib\MSIS;..\STlib\STM32F10x_StdPeriph_Driver\inc;..\HardDriver\can;..\HardDriver\delay;..\HardDriver\eye_led;..\HardDriver\usart3;..\HardDriver\touch_key;..\HardDriver\timer;..\App\app_init;..\App\can_deal;..\App\cmd_analyze;..\App\top_ear_led_control;..\App\eye_led_control;..\App\my_types;..\App\receive_ring_buffer;..\App\top_led_control;..\App\xf_voice;..\App\crc_lookup;..\App\cmd_execute;..\HardDriver\top_ear_led;..\HardDriver\watch_dog
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c config.h
  group App
    ../App/app_init/: app_init.c
    ../App/eye_led_control/: eye_led_control.c
    ../App/can_deal/: can_receive.c can_send.c
    ../App/receive_ring_buffer/: receive_ring_buffer.c
    ../App/xf_voice/: xf_voice.c
    ../App/crc_lookup/: crc_lookup.c
    ../App/my_types/: my_types.c
    ../App/cmd_execute/: cmd_execute.c
    ../App/cmd_analyze/: cmd_analyze.c
    ../App/top_ear_led_control/: top_ear_led_control.c
  group Driver
    ../HardDriver/usart3/: usart3.c
    ../HardDriver/can/: can.c
    ../HardDriver/delay/: delay.c
    ../HardDriver/eye_led/: eye_led.c
    ../HardDriver/top_ear_led/: top_ear_led.c
    ../HardDriver/touch_key/: touch_key.c
    ../HardDriver/timer/: timer3.c timer2.c timer4.c
    ../HardDriver/watch_dog/: watch_dog.c
  group STLib
    ../STlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c
  group CMSIS
    ../STlib/MSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ../STlib/StartUp/: startup_stm32f10x_md.s
